# Keil uVision project bk3435.uvproj, settings and files
target BK3435_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3435_ble_app +hex
  AfterMake: fromelf --bin --output .\output\app\bk3435_ble_app.bin .\obj\bk3435_ble_app.axf
  AfterMake: .\output\encrypt_app.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<tuya_ble_config_bk3431q.h>
  c misc: --diag_suppress=177,550,186;
  c include: .\config;.\app;..\..\sdk\plactform\arch;..\..\sdk\plactform\arch\compiler;..\..\sdk\plactform\arch\ll;..\..\sdk\plactform\arch\boot;..\..\sdk\plactform\arch\main;..\..\sdk\plactform\driver\pwm;..\..\sdk\plactform\driver\adc;..\..\sdk\plactform\driver\audio;..\..\sdk\plactform\driver\wdt;..\..\sdk\plactform\driver\rtc;..\..\sdk\plactform\driver\i2c;..\..\sdk\plactform\driver\utc;..\..\sdk\plactform\driver\ir;..\..\sdk\plactform\driver\spi;..\..\sdk\plactform\driver\plf;..\..\sdk\plactform\driver\counter;..\..\sdk\plactform\driver\gpio;..\..\sdk\plactform\driver\intcntl;..\..\sdk\plactform\driver\icu;..\..\sdk\plactform\driver\intc;..\..\sdk\plactform\driver\flash;..\..\sdk\plactform\driver\timer;..\..\sdk\plactform\driver\reg;..\..\sdk\plactform\driver\uart;..\..\sdk\plactform\driver\emi;..\..\sdk\ble_stack\peripheral\com\rwble;..\..\sdk\ble_stack\peripheral\com\rwble_hl;..\..\sdk\ble_stack\peripheral\com\rwble;..\..\sdk\ble_stack\peripheral\com\rwip\api;..\..\sdk\ble_stack\peripheral\com\rwble_hl;..\..\sdk\ble_stack\peripheral\src;..\..\sdk\plactform\reg;..\..\sdk\plactform\driver\syscntl;..\..\sdk\plactform\rom\hci;..\..\sdk\ble_stack\peripheral\inc;..\..\sdk\ble_stack\peripheral\inc\hci;..\..\sdk\ble_stack\peripheral\inc\h4tl;..\..\sdk\ble_stack\peripheral\inc\ke;..\..\sdk\ble_stack\peripheral\inc\nvds;..\..\sdk\ble_stack\peripheral\inc\ea;..\..\sdk\ble_stack\peripheral\inc\em;..\..\sdk\ble_stack\peripheral\inc\ahi;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gap\gapc;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gap\gapm;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gap\smpc;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gap\smpm;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt\attc;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt\attm;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt\atts;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt\gattc;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt\gattm;..\..\sdk\ble_stack\peripheral\inc\ble\hl\l2c\l2cc;..\..\sdk\ble_stack\peripheral\inc\ble\hl\l2c\l2cm;..\..\sdk\ble_stack\peripheral\inc\ble\ll\em;..\..\sdk\ble_stack\peripheral\inc\ble\ll\llc;..\..\sdk\ble_stack\peripheral\inc\ble\ll\lld;..\..\sdk\ble_stack\peripheral\inc\ble\ll\llm;..\..\sdk\ble_stack\peripheral\com\rwip\api;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gap;..\..\sdk\ble_stack\peripheral\inc\ble\hl\gatt;..\..\sdk\ble_stack\common\prf;..\..\sdk\ble_stack\common\profiles\dis\diss\src;..\..\sdk\ble_stack\common\profiles\bas\bass\src;..\..\sdk\ble_stack\common\profiles\ancs\ancsc\api;..\..\sdk\ble_stack\common\profiles\ancs\ancsc\src;..\..\sdk\ble_stack\common\profiles\ancs;..\..\sdk\ble_stack\common\profiles\FCC0\api;..\..\sdk\ble_stack\common\profiles\FCC0\src;..\..\sdk\ble_stack\common\profiles\FCC0\util;..\..\sdk\ble_stack\common\profiles\FEE0\api;..\..\sdk\ble_stack\common\profiles\FEE0\src;..\..\sdk\ble_stack\common\profiles\hogp;..\..\sdk\ble_stack\common\profiles\hogp\hogpd\api;..\..\sdk\ble_stack\common\profiles\hogp\hogpd\src;..\..\libs;..\..\sdk\ble_stack\common\profiles\wechat\api;..\..\sdk\ble_stack\common\profiles\wechat\src;.\wechat;..\..\sdk\ble_stack\common\profiles\bas\bass;..\..\sdk\ble_stack\common\profiles\bas\bass\api;..\..\sdk\ble_stack\common\profiles\dis\diss;..\..\sdk\ble_stack\common\profiles\dis\diss\api;..\..\sdk\ble_stack\common\profiles\FFF0\api;..\..\sdk\ble_stack\common\profiles\FFF0;..\..\sdk\ble_stack\common\profiles\oad\api;..\..\sdk\ble_stack\common\profiles\sdp\api;..\..\sdk\ble_stack\common\profiles\sdp\src;..\..\sdk\plactform\com\api;..\..\sdk\ble_stack\peripheral\com\rf\api;..\..\sdk\ble_stack\peripheral\com\rwble;..\..\sdk\ble_stack\peripheral\com\rwble_hl;..\..\sdk\ble_stack\peripheral\com\rwip\api;..\..\sdk\ble_stack\peripheral\inc\dbg;..\..\sdk\ble_stack\common\prf;..\..\..\tuya_ble_sdk_demo\src\cpt\easylogger\inc;..\..\..\tuya_ble_sdk_demo\src\cpt\easylogger\plugins\file;..\..\..\tuya_ble_sdk_demo\src\cpt\easylogger\plugins\flash;..\..\..\tuya_ble_sdk_demo\src\cpt\simpleflash;..\..\..\tuya_ble_sdk_demo\src\suble;..\..\..\tuya_ble_sdk_demo\src\app\tuya_ble_sdk_demo;..\..\..\tuya_ble_sdk_demo\src\app\tuya_ble_sdk_demo\port;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\app\product_test;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\app\uart_common;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\extern_components\mbedtls;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\port;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\sdk\include;..\..\..\tuya_ble_sdk_demo\src\tuya_ble_sdk\sdk\lib;..\..\..\tuya_ble_sdk_demo\src\app\app_common;..\..\..\tuya_ble_sdk_demo\src\app\app_lock
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: ..\..\sdk\project_files\peripheral_gatt_link_app.txt
  link misc: --entry sys_Reset
  group app_lock
    ../../../tuya_ble_sdk_demo/src/app/app_lock/: lock_common.h lock_common.c lock_hard.c lock_dp_parser.c lock_dp_report.c lock_timer.c lock_music.c lock_test.c
  group app_common
    ../../../tuya_ble_sdk_demo/src/app/app_common/: app_common.h app_common.c app_flash.c app_active_report.c app_test.c app_port.c app_port.h
  group tuya_ble_sdk_demo
    ../../../tuya_ble_sdk_demo/src/app/tuya_ble_sdk_demo/: tuya_ble_app_demo.h tuya_ble_app_demo.c tuya_ble_app_ota.c
  group tuya_ble_sdk
    ../../../tuya_ble_sdk_demo/src/app/tuya_ble_sdk_demo/port/: tuya_ble_config_bk3431q.h tuya_ble_port_bk3431q.h tuya_ble_port_bk3431q.c
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/sdk/include/: tuya_ble_api.h
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/sdk/src/: tuya_ble_api.c tuya_ble_utils.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_event.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_data_handler.c tuya_ble_event_handler.c tuya_ble_gatt_send_queue.c tuya_ble_mutli_tsf_protocol.c tuya_ble_event_handler_weak.c
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/port/: tuya_ble_port.c tuya_ble_port_peripheral.c
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/app/product_test/: tuya_ble_app_production_test.c
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/app/uart_common/: tuya_ble_app_uart_common_handler.c
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/sdk/lib/: tuya_ble_sdk_lib_arm9e-s_little_endian.lib
  group cpt_mbedtls
    ../../../tuya_ble_sdk_demo/src/tuya_ble_sdk/extern_components/mbedtls/: aes.c md5.c sha1.c sha256.c
  group suble
    ../../../tuya_ble_sdk_demo/src/suble/: suble_common.h suble_common.c suble_scan_adv.c suble_gap.c suble_svc.c suble_gpio.c suble_uart.c suble_flash.c suble_timer.c suble_key.c suble_battery.c suble_util.c suble_test.c README.md
  group cpt_simpleflash
    ../../../tuya_ble_sdk_demo/src/cpt/simpleflash/: sf_nv.c sf_nv.h sf_port.c sf_port.h sf_mem.c sf_mem.h
  group cpt_easylogger
    ../../../tuya_ble_sdk_demo/src/cpt/easylogger/inc/: elog_cfg.h elog.h
    ../../../tuya_ble_sdk_demo/src/cpt/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../../../tuya_ble_sdk_demo/src/cpt/easylogger/port/: elog_port.c
  group System
    ./app/: arch_main.c
    ../../sdk/plactform/arch/boot/: boot_handlers.s boot_vectors.s
    ../../sdk/project_files/: peripheral_stack_symbol.txt
  group config
    ./config/: rwip_config.h rwprf_config.h user_config.h
  group ip
    ../../sdk/ble_stack/peripheral/com/rwble/: rwble.c
    ../../sdk/ble_stack/peripheral/com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack/peripheral/com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/driver/icu/: icu.c
    ../../sdk/plactform/driver/gpio/: gpio.c
    ../../sdk/plactform/driver/flash/: flash.c
    ../../sdk/plactform/driver/emi/: emi.c
    ../../sdk/plactform/driver/adc/: adc.c
    ../../sdk/plactform/driver/intc/: intc.c
    ../../sdk/plactform/driver/pwm/: pwm.c
    ../../sdk/plactform/driver/timer/: timer.c
    ../../sdk/plactform/driver/uart/: uart.c
    ../../sdk/plactform/driver/wdt/: wdt.c
    ../../sdk/ble_stack/peripheral/com/rf/src/: rf_xvr.c
    ../../sdk/plactform/driver/rtc/: rtc.c
  group profile
    ../../sdk/ble_stack/common/prf/: prf.c prf_utils.c
    ../../sdk/ble_stack/common/profiles/FFF0/src/: fff0s.c fff0s_task.c
  group app
    ./app/: app.c app_fff0.c app_task.c
  group lib
    ../../libs/: bk3435_ble_encrypt.lib bk3435_fcc_mode.lib bk3435_pn9_mode.lib
